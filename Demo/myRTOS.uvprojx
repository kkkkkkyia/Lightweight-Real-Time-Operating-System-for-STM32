# Keil uVision project myRTOS.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: myRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\arch\arm\cortex-m3;..\kernel\include;..\platform;..\STM32FWlib\serial;..\STM32FWlib\STM32F10xFWLib\inc;..\kernel;..\Demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MyRTOS
    ../kernel/source/: my_mem.c my_scheduler.c my_task.c my_time.c my_queue.c my_mutex.c my_kernel.c my_sem.c my_timer.c
  group CortexM3
    ./: startup_stm32f1xx.s FreeRTOS.h
    ../arch/arm/cortex-m3/: port.c portmacro.h my_arch.c cortexM3_macro_rvds.s
  group FWLib
    ../STM32FWlib/serial/: serial.c
    ../STM32FWlib/STM32F10xFWLib/src/: stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ./: main.c
  group Platform
    ../platform/: platform.c
